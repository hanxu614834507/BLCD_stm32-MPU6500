# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\config;..\HARDWARE\GPIO_Init;..\HARDWARE\BLDCTIM_Init;..\HARDWARE\CAN;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\BSP;..\HARDWARE\TIME;..\HARDWARE\time2;..\HARDWARE\CURRENT;..\HARDWARE\DS18B20;..\HARDWARE\MPU6500;..\HARDWARE\TIM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/GPIO_Init/: GPIO_Init.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/time2/: time2.c
    ../HARDWARE/CURRENT/: current.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/MPU6500/: mpu6500.c
    ../HARDWARE/TIM3/: time3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_spi.c
  group README
    ../: readme.txt
